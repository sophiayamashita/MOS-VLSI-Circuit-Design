<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Apr 7 01:08:41 2024</timestamp>
			<uuid>{40b4c90f-d85e-4826-869a-f793fe3fa83e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/viterbi/03/palapart/work_gpdk045/ee477FinalProject/XOR_6TG_components/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/viterbi/03/palapart/work_gpdk045/ee477FinalProject/XOR_6TG_components/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/viterbi/03/palapart/simulation/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/viterbi/03/palapart/simulation/results/maestro/ExplorerRun.0</simdir>
		</historyentry>
	</history>
</setupdb>
